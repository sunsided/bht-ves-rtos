# Keil uVision project mt.uvproj, settings and files
target Target 1 (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: mt
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group rtos_impl
    ./rtos_impl/: rtos.c v24.c v24.h timer.h timer.c system.h threads.c threads.h systemcall.c systemcall.h time.c semaphores.c semaphores.h
  group rtos
    ./rtos/: datatypes.h rtos.h rtos_semaphores.h rtos_threads.h rtos_time.h
  group rtos_impl_syscalls
    ./rtos_impl/syscall/: syscall_register_thread.h syscall_sleep.h syscall_semaphore.h
